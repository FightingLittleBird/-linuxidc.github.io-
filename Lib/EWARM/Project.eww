<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MK_A9_FreeRtos.ewp</path>
  </project>
  <batchBuild />
</workspace>
