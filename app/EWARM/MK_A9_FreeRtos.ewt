<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>MK_A9_FreeRtos</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\startup_stm32f051x8.s</name>
      </file>
    </group>
    <group>
      <name>User</name>
      <group>
        <name>MK_A9</name>
        <file>
          <name>$PROJ_DIR$\..\MK_A9\Src\coding_switch.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\MK_A9\Src\coding_switch2.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\MK_A9\Src\communication_code.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\MK_A9\Src\flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\MK_A9\Src\Gcode.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\MK_A9\Src\gpio_spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\MK_A9\Src\key_Process.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\MK_A9\Src\MK_A9.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\MK_A9\Src\protocol.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\MK_A9\Src\stm32f0xx_lp_modes.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\MK_A9\Src\usr_stdlib.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\MK_A9\Src\usr_uart_dma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\MK_A9\Src\usr_usart.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\Src\dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f0xx_hal_msp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f0xx_hal_timebase_TIM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f0xx_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\usart.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Drivers</name>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\..\Src\system_stm32f0xx.c</name>
      </file>
    </group>
    <group>
      <name>STM32F0xx_HAL_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F0xx_HAL_Driver\Src\stm32f0xx_hal.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>LIB</name>
    <file>
      <name>$PROJ_DIR$\..\lib\HAL_Lib.a</name>
    </file>
  </group>
</project>


