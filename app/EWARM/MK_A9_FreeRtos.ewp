# IAR project MK_A9_FreeRtos.ewp, settings and files
configuration MK_A9_FreeRtos (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F051x8; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include; ../MK_A9/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MK_A9_FreeRtos.hex
  ILINK.IlinkOutputFile: MK_A9_FreeRtos.out
  ILINK.IlinkIcfFile: stm32f051x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f051x8.s
  group Application/User
    ../Src/: dma.c gpio.c iwdg.c main.c rtc.c spi.c stm32f0xx_hal_msp.c stm32f0xx_hal_timebase_TIM.c stm32f0xx_it.c usart.c
  group Application/User/MK_A9
    ../MK_A9/Src/: coding_switch.c coding_switch2.c communication_code.c flash.c Gcode.c gpio_spi.c key_Process.c MK_A9.c protocol.c stm32f0xx_lp_modes.c usr_stdlib.c usr_uart_dma.c usr_usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c
  group LIB
    ../lib/: HAL_Lib.a
